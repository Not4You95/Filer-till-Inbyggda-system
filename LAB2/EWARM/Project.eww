<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LAB2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\TEST\TEST.ewp</path>
  </project>
  <batchBuild/>
</workspace>


